# IAR project 8_mhz_gpio_clock.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; NRF51
  ICCARM.CCIncludePath2: ..\..\..\..\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 8_mhz_gpio_clock_iar.hex
  ILINK.IlinkOutputFile: 8_mhz_gpio_clock_iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main.c
    ../../../../Source/templates/: system_nrf51.c
